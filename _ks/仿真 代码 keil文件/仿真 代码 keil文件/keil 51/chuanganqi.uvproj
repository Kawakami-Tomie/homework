# Keil uVision project chuanganqi.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: chuanganqi +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h DHT11.c DHT11.h DS18B20.c DS18B20.h LCD1602.c LCD1602.h OneWire.c OneWire.h Timer0.c Timer0.h
