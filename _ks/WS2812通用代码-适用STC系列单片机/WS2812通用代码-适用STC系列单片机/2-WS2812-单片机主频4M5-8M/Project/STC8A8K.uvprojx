# Keil uVision project STC8A8K.uvprojx, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC8A8K64S4A12 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\C_AND_H
  group Source Group 1
    ./: STARTUP.A51
    ../C_AND_H/: main.c WS2812.c
  group include
    ../C_AND_H/: all.h WS2812.h
