# Keil uVision project 定时器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 定时器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c charcode.c charcode.h Delay.c Delay.h LCD9648.c LCD9648.h lcddriver.c ST7565.h
